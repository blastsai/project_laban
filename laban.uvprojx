# Keil uVision project laban.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: MKL46Z256VLL4 NXP
  pack: NXP.MKL46Z4_DFP.10.0.3
  cpu: IRAM(0x1fffe000,0x8000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: laban
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: .\RTE\Device\MKL46Z256VLL4\MKL46Z256xxx4_flash.scf
  group Source Group 1
    ./: main.c mag3110.c mag3110.h system.c system.h lcd.c lcd.h
software components: CMSIS:CORE 5.0.1, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.0.0, Device:SDK Drivers:flash 3.0.0, Device:SDK Drivers:i2c 2.0.5, Device:Startup 1.0.0
